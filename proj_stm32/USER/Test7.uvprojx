# Keil uVision project Test7.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: Template +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\APP\LED;..\APP\USART3;..\APP\TIMER;..\APP\BEEP;..\APP\KEY;..\APP\LCD;..\APP\PWM_Motor;..\APP\EXTI;..\APP\RPLIDAR
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c misc.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_exti.c stm32f4xx_dma.c stm32f4xx_fsmc.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/delay/: delay.c
  group APP
    ../APP/LED/: led.c
    ../APP/USART3/: usart3.c
    ../APP/TIMER/: timer.c
    ../APP/BEEP/: beep.c
    ../APP/KEY/: key.c
    ../APP/LCD/: lcd.c
    ../APP/PWM_Motor/: pwm_motor.c
    ../APP/EXTI/: exti.c
    ../APP/RPLIDAR/: rplidar.c
